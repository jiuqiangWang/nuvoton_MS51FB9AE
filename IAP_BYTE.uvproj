# Keil uVision project IAP_BYTE.uvproj, settings and files
target IAP_BYTE (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: IAP_BYTE +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\Common;.\Startup;.\Code
  group Source Group 1
    ./Code/: IAP_BYTE.c
  group Common
    ./Common/: Common.c Delay.c
  group Startup
    ./Startup/: STARTUP.A51
